# Repository kai0930/73-para-board

File README.md:

# 東京科学大学ロケットサークルCREATE C-73J 開放基板

## KiCad design hardware/開放基板/開放基板.kicad_pcb

Parts:
C1, C19: 10u; C_0603_1608Metric
C2, C16, C18, C20, C21: 0.1u; C_0603_1608Metric
C3, C6, C9: 0.33u; C_0603_1608Metric
C4, C7, C10, C14, C17: 2.2u; C_0603_1608Metric
C5, C8, C11: 47u; C_Elec_6.3x5.8
C12, C13: 0.1; C_0603_1608Metric
C15: 10n; C_0603_1608Metric
D1, D2, D5: D_1206_3216Metric
D3, D4, D6: LED; LED_0603_1608Metric
ICM-42688-P1: ICM42688_TDK
J1: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5
J2: Conn_01x05_Socket; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J3: USB_B_Micro; USB_Micro-B_HRS_ZX62R-B-5P
J4: Conn_01x07_Socket; JST_PH_S7B-PH-K_1x07_P2.00mm_Horizontal
J5: Conn_01x12_Pin; PinHeader_2x06_P2.54mm_Vertical
NJM2391DL1-05-1, NJM2391DL1-05-2, NJM2391DL1-33-1: NJM2391DL1-33
R1, R2, R5, R6, R7, R8, R9, R10: 10k; R_0603_1608Metric
R3: 1KΩ; R_0603_1608Metric
R4, R11: 1k; R_0603_1608Metric
U1: ESP32-S3-WROOM-1
U2: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: LPS25HB; ST_HLGA-10_2.5x2.5mm_P0.6mm_LayoutBorder3x2y

Connections:
+3.3V: C1.2, C7.1, C8.1, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, D2.2 (A), D3.2 (A), ICM-42688-P1.5 (VDDIO), ICM-42688-P1.8 (VDD), J1.4 (VDD), J5.1, NJM2391DL1-33-1.OUT, R1.1, R2.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, U1.2 (3V3), U2.5 (Vio), U3.1 (Vdd_IO), U3.10 (VDD)
+5V: C4.1, C5.1, C6.1, C12.1, D1.2 (A), D2.1 (K), J3.1 (VBUS), J5.2, NJM2391DL1-05-1.OUT, NJM2391DL1-33-1.IN, U2.3 (VDD)
/5V_SERVO: C10.1, C11.1, C14.1, D5.2 (A), J4.7, NJM2391DL1-05-2.OUT
/CAN_H: J2.1, J4.2, J5.11, U2.7 (CANH)
/CAN_L: J2.2, J4.3, J5.10, U2.6 (CANL)
/CLK: ICM-42688-P1.13 (AP_SCL/AP_SCLK), J5.7, U1.15 (IO3), U3.2 (SCL)
/D+: J3.3 (D+), U1.14 (IO20)
/D-: J3.2 (D-), U1.13 (IO19)
/ESP2MCP: J5.3, U1.23 (IO21), U2.4 (RXD)
/ICM_CS: ICM-42688-P1.12 (AP_CS), J5.8, U1.17 (IO9)
/IO2: J1.7 (DAT0), R9.2, U1.38 (IO2)
/IO4: J1.8 (DAT1), R10.2, U1.4 (IO4)
/IO12: J1.1 (DAT2), R5.2, U1.20 (IO12)
/IO13: J1.2 (DAT3/CD), R6.2, U1.21 (IO13)
/IO14: J1.5 (CLK), R8.2, U1.22 (IO14)
/IO15: J1.3 (CMD), R7.2, U1.8 (IO15)
/LED: R4.1, U1.5 (IO5)
/LPS_CS: J5.9, U1.10 (IO17), U3.6 (~CS)
/MCP2ESP: J5.4, U1.24 (IO47), U2.1 (TXD)
/MISO: ICM-42688-P1.1 (AP_SDO/AP_AD0), J5.6, U1.11 (IO18), U3.5 (SA0)
/MOSI: ICM-42688-P1.14 (AP_SDA/AP_SDIO/AP_SDI), J5.5, U1.12 (IO8), U3.4 (SDA)
/SERVO_PWM: J4.1, U1.35 (IO42)
/VCC_ACTUATOR: C9.1, D5.1 (K), J2.5, J4.6, NJM2391DL1-05-2.IN
/VCC_LOGIC: C3.1, D1.1 (K), J2.4, J4.5, NJM2391DL1-05-1.IN
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, D4.1 (K), D6.1 (K), ICM-42688-P1.6 (GND), ICM-42688-P1.9 (INT2/FSYNC/CLKIN), J1.6 (VSS), J1.9 (DET_B), J2.3, J3.5 (GND), J4.4, J5.12, NJM2391DL1-05-1.GND, NJM2391DL1-05-2.GND, NJM2391DL1-33-1.GND, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.2 (VSS), U2.8 (STBY), U3.3 (GND), U3.8 (GND), U3.9 (GND)
unnamed: D3.1 (K), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D6.2 (A), R11.2
unnamed: J1.10 (DET_A), R3.1
unnamed: C2.1, R2.2, U1.3 (EN)
unnamed: R1.2, U1.27 (IO0)

Notes on the sheet:
Sensors
電源管理->開放
開放->通信
Debug Pins
MCU
Power
Connector
microSDカードが挿入されたらLEDが点灯
CAN
SERVP_PWM：サーボモータ制御用PWM CAH_H：CAN通信HIGH CAH_L：CAN通信LOW GND：GND VCC_LOGIC：ロジック用LiPoからの電源供給 VCC_ACTUATOR：アクチュエーター用LiPoからの電源供給 5V_SERVO：サーボモータ用電源（5V）
USB
Micro SD

Board: 4 copper layers, 76.6 x 72.6 mm, 50 parts (0 on the bottom side), 31 nets.

## KiCad design Avi_73J_ParaBoard_v2.kicad_pcb

Parts:
C1, C2, C4, C5: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C9: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C10: 47u; C_Elec_6.3x5.8
C8, C11: 0.33u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D5: LED; LED_0603_1608Metric
D3, D4: D_1206_3216Metric
ICM-20602-1: ICM20602
ILG-2P1, ILG-2P2, ILG-2P3, ILG-2P4: IL-G-2P
ILG-3P1: IL-G-3P
J1: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5
J2: USB4110-GF-A; USB4110-GF-A_GCT
LPS25HB-1: LPS25HB
NJM2391DL1-05-1, NJM2391DL1-33-1: NJM2391DL1-33
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5: 10k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R7, R8, R10: 1k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R9: 120; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R11, R12: 5.1k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
U1: ESP32-WROOM-32E; ESP32-WROOM-32D
U2: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: FT232RL; IC28_SSOP-28_FTD

Connections:
3.3V: C2.1, C4.2, C6.1, C7.1, D3.2 (A), ICM-20602-1.1 (VIO), ICM-20602-1.10 (VDD), J1.4 (VDD), LPS25HB-1.1 (VDD), NJM2391DL1-33-1.OUT, R1.1, R2.1, R3.1, R4.1, R5.1, R7.1, U1.2 (VDD), U2.5 (Vio), U3.4 (VCCIO), U3.17 (3V3OUT)
5V: C3.2, C5.2, C9.1, C10.1, D4.2 (A), ILG-3P1.2, NJM2391DL1-05-1.OUT, U2.3 (VDD)
CAN_H: ILG-2P1.1, ILG-2P2.1, R9.1, U2.7 (CANH)
CAN_L: ILG-2P1.2, ILG-2P2.2, R9.2, U2.6 (CANL)
CAN_RX_ESP: U1.29 (IO5), U2.1 (TXD)
CAN_RX_MCP: U1.28 (IO17), U2.4 (RXD)
CC1: J2.A5 (CC1), R11.1
CC2: J2.B5 (CC2), R12.2
EN: C1.1, R1.2, U1.3 (EN), U3.3 (RTS#)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D2.1 (K), ICM-20602-1.8 (FSY), ICM-20602-1.9 (GND), ILG-2P3.1, ILG-2P4.1, ILG-3P1.3, J1.6 (VSS), J1.9 (DET_B), J2.A1-B12 (GND), J2.A12-B1 (GND), LPS25HB-1.8 (GND), NJM2391DL1-05-1.GND, NJM2391DL1-33-1.GND, R10.2, R11.2, R12.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (VSS), U2.8 (STBY), U3.7 (GND), U3.18 (GND), U3.21 (GND), U3.25 (AGND), U3.26 (TEST)
ICM_CS: ICM-20602-1.5 (CS), U1.26 (IO4)
IO0: R2.2, U1.25 (IO0), U3.2 (DTR#)
LED: R8.1, U1.36 (IO22)
LPS_CS: LPS25HB-1.5 (CS), U1.14 (IO12)
MISO: ICM-20602-1.4 (SO), LPS25HB-1.4 (SDO), U1.23 (IO15)
MOSI: ICM-20602-1.3 (SI), LPS25HB-1.3 (SDA/SDI), U1.24 (IO2)
unnamed: D1.2 (A), J1.10 (DET_A)
unnamed: D1.1 (K), R7.2
unnamed: D2.2 (A), R8.2
unnamed: D5.1 (K), R10.1
RXD0_ESP: U1.34 (RXD0/IO3), U3.1 (TXD)
RXD_FT232: U1.35 (TXD0/IO1), U3.5 (RXD)
SD_CS: J1.2 (DAT3/CD), U1.27 (IO16)
SD_MISO: J1.7 (DAT0), R4.2, U1.31 (IO19)
SD_MOSI: J1.3 (CMD), R3.2, U1.37 (IO23)
SD_SPC: J1.5 (CLK), R5.2, U1.30 (IO18)
SERVO_PIN: ILG-3P1.1, U1.11 (IO26)
SPC: ICM-20602-1.2 (SC), LPS25HB-1.2 (SCL/SPC), U1.16 (IO13)
USBDM: J2.A7 (DN1), J2.B7 (DN2), U3.16 (USBDM)
USBDP: J2.A6 (DP1), J2.B6 (DP2), U3.15 (USBDP)
VBUS: D5.2 (A), J2.A4-B9 (VBUS), J2.A9-B4 (VBUS), U3.20 (VCC)
VCC_ACTUATOR: C11.1, D4.1 (K), ILG-2P4.2, NJM2391DL1-05-1.IN
VCC_LOGIC: C8.1, D3.1 (K), ILG-2P3.2, NJM2391DL1-33-1.IN

Notes on the sheet:
microSD ESP32 ピン対応表
他の2基板とのCAN通信のトランシーバー
USB SERIAL
Power
DAT2 DAT3 CMD CLK DAT0 DAT1
N.C. CS MOSI SCLK MISO N.C.
CAN
microSD
Senors
ESP32にUSB-TypeCで書き込む
電源管理基板から供給された 5V→3.3V 9V→5V に降圧する
SPI通信でマイクロSDカードにデータを保存 SPIバスはセンサーとは別
ESP32
MCU

Board: 2 copper layers, 56.0 x 56.0 mm, 41 parts (10 on the bottom side), 33 nets.

File ParaBoard_Parts.csv:

"Reference","Value","Datasheet","Footprint","Qty","DNP"
"C1,C2,C4,C5","0.1u","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","4",""
"C3","4.7u","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"C6,C9","2.2u","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","2",""
"C7,C10","47u","~","Capacitor_SMD:C_Elec_6.3x5.8","2",""
"C8,C11","0.33u","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","2",""
"D1,D2,D5","LED","~","LED_SMD:LED_0603_1608Metric","3",""
"D3,D4,ICM-20602-1,ILG-2P1,ILG-2P2,ILG-2P3,ILG-2P4,ILG-3P1,LPS25HB-1,NJM2391DL1-05-1,NJM2391DL1-33-1","~","-- ミックスされた値 --","-- ミックスされた値 --","11",""
"J1","Micro_SD_Card_Det_Hirose_DM3AT","https://www.hirose.com/product/en/download_file/key_name/DM3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","Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5","1",""
"J2","USB4110-GF-A","USB4110-GF-A","USB_connector:USB4110-GF-A_GCT","1",""
"R1,R2,R3,R4,R5","10k","~","-- ミックスされた値 --","5",""
"R7,R8,R10","1k","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","3",""
"R9","120","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","1",""
"R11,R12","5.1k","~","Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder","2",""
"U1","ESP32-WROOM-32E","https://www.espressif.com/sites/default/files/documentation/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","RF_Module:ESP32-WROOM-32D","1",""
"U2","MCP2562-E-SN","http://ww1.microchip.com/downloads/en/DeviceDoc/25167A.pdf","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","1",""
"U3","FT232RL","","Serial_conversion:IC28_SSOP-28_FTD","1",""

## Commit log

2024-08-11 様々な修正
2025-01-07 一時的にコミット
2025-02-06 すべてのファイルを削除
2025-02-06 Readmeを作成
2025-02-06 KiCadプロジェクトを追加
2025-02-07 ESP-IDテストプロジェクトを作成
2025-02-07 LPS25HB、ICM20602のライブラリを作成
2025-02-07 動作試験用のコードを一部作成
2025-02-07 ドキュメントを追加
2025-02-07 サーボのライブラリを作成
2025-02-08 動作試験コードを作成
2025-02-14 新基板向けの修正
2025-02-14 不要なファイルを削除
2025-02-20 テストコードを作成
2025-02-22 いくつかの修正
2025-03-07 WSL用に修正
2025-03-07 メインファイルをcppに変更
2025-03-13 開放基板のコードを作成
2025-03-17 機能を追加
